# Repository mcign/pcb

File README.md:

# MCIGN

## Introduction
This PCB design is for a keyless motorcycle ignition controlled by a smartphone BLE app. The PCB is designed to be installed in a gutted ignition unit, resulting in a stock appearance. A BGM111 wireless modulecontrols the main board, and two relays are used to switch the power on and off. A auxillary relay board can be used for ignitions that require more than 2 relays.

The BGM111 module was chosen because it has already been FCC certified, which normally makes it much easier to sell the hardware without violating FCC regulations. However, this project is exempt from the required testing because it is "a digital device utilized exclusively in any transportation vehicle including motor vehicles." The project is now being ported to the nRF51822 chip for several reason:

 * It is cheaper
 * Cheap generic breakout boards are available
 * Supports open source tools (gcc & make), which have less bugs, more documentation, and better integration with git than Simplicity Studio, which is required for the BGM111
 * An automotive grade (AEC-Q100) drop-in replacement is available (nRF51824), allowing the hardware to be built to automotive standards

## Usage
After assembly, the BGM111 module can be flashed with the MCIGN firmware via the exposed test pads. A 3d-printable programmer can be built using files in the cad/ directory and cheap [https://en.wikipedia.org/wiki/Pogo_pin](pogo pins) to flash PCBs without soldering wires to the test pads. Once flashed, the stock ignition switch should be closely examined to determine which wires are connected when the igition is in the "on" position. A wiring diagram from the service manual can also be helpful, but certain parts used to prevent hotwiring usually aren't shown on the diagram. A ground wire is usually not included in the connector, so another path to ground must be found. For a stock appearance, the body of the ignition itself can potentially be used as it is bolted to the frame, avoiding any extra wires coming out of the ignition housing.

## Contributing
This project is in its early stages, and all contributions are greatly appreciated. Features, bug fixes, documentation, etc can be submitted with a github pull request.

## Help
Please make a github issue for any technical questions, feature requests, etc.

## License
This project is released under GPLv3.

## EAGLE design bt_board.brd

Parts:
3V: GND; TEST_PAD
12V: 12V; HOLE_2MM
BGM111: BGM111
D1: FM5817-W; DIOM5025X231N
GND: GND; HOLE_2MM
GND4: GND; TEST_PAD
Q1, Q2: 4N35S; SOT254P916X508-6N
R1, R2: 50-100; M0805
R3: 100; M0805
R4: 33M; R0603
R5: 3.3M; R0603
RESET: GND; TEST_PAD
SWO, SWO1: GND; TEST_PAD
U$1, U$2: 103-1CH-C-12VDC
U$3, U$4, U$5, U$6: HOLE_2MM
U$7: HOLE_1.5MM

Connections:
+12V: D1.1 (K), R4.2, U$1.P$3, U$2.P$4; also elsewhere on the board
GND: BGM111.P$1 (GND), BGM111.P$12 (GND), BGM111.P$20 (GND), BGM111.P$31 (GND), GND.P$1, GND4.P$1, Q1.2 (CATHODE), Q1.4 (EMITTER), Q2.2 (CATHODE), Q2.4 (EMITTER), R5.1; also elsewhere on the board
unnamed: BGM111.P$5 (PA0), R4.1, R5.2
unnamed: BGM111.P$22 (PF1), SWO1.P$1
unnamed: BGM111.P$21 (PF0), SWO.P$1
unnamed: Q2.1 (ANODE), R1.2
unnamed: Q1.1 (ANODE), R2.2
unnamed: BGM111.P$30 (RESET), RESET.P$1
unnamed: Q1.5 (COLLECTOR), U$1.P$4
unnamed: BGM111.P$9 (PA4), R1.1, U$7.P$1
unnamed: BGM111.P$10 (PA5), R2.1
unnamed: U$1.P$2, U$3.P$1
unnamed: U$1.P$1, U$6.P$1
unnamed: U$2.P$2, U$4.P$1
unnamed: Q2.5 (COLLECTOR), U$2.P$3
unnamed: R3.2, U$5.P$1
unnamed: R3.1, U$2.P$1
unnamed: 12V.P$1, D1.2 (A)
VDD: 3V.P$1, BGM111.P$29 (VDD); also elsewhere on the board

Board: 2 copper layers, 32.0 x 29.5 mm, 26 parts (15 on the bottom side), 19 nets.

Other parts of the board:
SUPPLY1:C1, SUPPLY1:C2: 1uF; C0805
SUPPLY1:PS1: NCV8715SQ33T2G; SOT65P210X110-5N

Their connections:
+12V: SUPPLY1:C2.1, SUPPLY1:PS1.4; also elsewhere on the board
GND: SUPPLY1:C1.2, SUPPLY1:C2.2, SUPPLY1:PS1.1, SUPPLY1:PS1.2, SUPPLY1:PS1.3; also elsewhere on the board
VDD: SUPPLY1:C1.1, SUPPLY1:PS1.5; also elsewhere on the board

## Commit log

2019-05-14 initial release
2019-05-14 add image of pcb layout to readme
2019-05-14 changed wording
2019-05-14 add cad model for pcb programmer
2019-05-14 add docs about automotive circuit design
